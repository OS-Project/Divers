# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; beaglebone
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include\; ..\..\..\..\..\..\include\hw\; ..\..\..\..\..\..\include\armv7a\; ..\..\..\..\..\..\include\armv7a\am335x\; ..\..\..\..\..\..\third_party\lwip-1.4.0\; ..\..\..\..\..\..\third_party\lwip-1.4.0\ports\cpsw\include\; ..\..\..\..\..\..\third_party\lwip-1.4.0\apps\httpserver_raw_io\; ..\..\..\..\..\..\examples\beaglebone\demo\; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\ipv4\; ..\..\..\..\..\..\third_party\fatfs\src\; ..\..\..\..\..\..\mmcsdlib\include\; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\lwip\; ..\..\..\..\..\..\third_party\lwip-1.4.0\apps\httpserver_raw_io\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: demo.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; beaglebone
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../../examples/beaglebone/demo/: demoEnet.c demoLedIf.c demoMain.c demoRtc.c demoSdFs.c demoSdRw.c demoTimer.c
    ../../../../../../binary/armv7a/ewarm/am335x/drivers/: drivers.a
    ../../../../../../third_party/fatfs/port/: fat_mmcsd.c
    ../../../../../../third_party/fatfs/src/: ff.c
    ../../../../../../third_party/lwip-1.4.0/apps/httpserver_raw_io/: httpd_io.c
    ../../../../../../binary/armv7a/ewarm/mmcsdlib/: libmmcsd.a
    ../../../../../../third_party/lwip-1.4.0/ports/cpsw/: lwiplib.c
    ../../../../../../binary/armv7a/ewarm/am335x/beaglebone/platform/: platform.a
    ../../../../../../binary/armv7a/ewarm/am335x/system_config/: system.a
    ../../../../../../binary/armv7a/ewarm/utils/: utils.a
