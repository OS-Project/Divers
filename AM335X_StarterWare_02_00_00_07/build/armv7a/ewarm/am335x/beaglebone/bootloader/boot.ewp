# IAR project boot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: beaglebone; MMCSD; am335x
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include\; ..\..\..\..\..\..\include\hw\; ..\..\..\..\..\..\include\armv7a\; ..\..\..\..\..\..\include\armv7a\am335x\; ..\..\..\..\..\..\bootloader\include\; ..\..\..\..\..\..\bootloader\include\armv7a\am335x\; ..\..\..\..\..\..\third_party\fatfs\src\; ..\..\..\..\..\..\mmcsdlib\include\; ..\..\..\..\..\..\nandlib\include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: boot.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x402F0400" "MMCSD" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: boot.out
  ILINK.IlinkIcfFile: boot.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: am335x TexasInstruments am335x
  ICCARM.CCDefines: NDEBUG; am335x; am335x_15x15; beaglebone; MMCSD
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include\; ..\..\..\..\..\..\include\hw\; ..\..\..\..\..\..\include\armv7a\; ..\..\..\..\..\..\include\armv7a\am335x\; ..\..\..\..\..\..\bootloader\include\; ..\..\..\..\..\..\third_party\fatfs\src\; ..\..\..\..\..\..\mmcsdlib\include\; ..\..\..\..\..\..\nandlib\include\
  ICCARM.CCOptLevel: 3
configuration MMCSD_Debug (ARM, debug)
  as the first configuration, except:
configuration MMCSD_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; beaglebone; MMCSD
  ICCARM.CCOptLevel: 3
configuration UART_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: beaglebone; UART; am335x
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x402F0400" "UART" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
configuration UART_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; beaglebone; UART
  ICCARM.CCOptLevel: 3
  postbuild: as above
  group (top)
    ../../../../../../bootloader/src/: bl_copy.c bl_hsmmcsd.c bl_main.c bl_uart.c
    ../../../../../../bootloader/src/armv7a/ewarm/: bl_init.S
    ../../../../../../system_config/armv7a/: mmu.c cache.c
    ../../../../../../system_config/armv7a/ewarm/: cp15.S
    ../../../../../../bootloader/src/armv7a/am335x/: bl_platform.c
    ../../../../../../third_party/xmodem/: crc16.c xmodem.c
    ../../../../../../binary/armv7a/ewarm/am335x/drivers/: drivers.a
    ../../../../../../third_party/fatfs/port/: fat_mmcsd.c
    ../../../../../../third_party/fatfs/src/: ff.c
    ../../../../../../binary/armv7a/ewarm/mmcsdlib/: libmmcsd.a
    ../../../../../../binary/armv7a/ewarm/am335x/beaglebone/platform/: platform.a
    ../../../../../../binary/armv7a/ewarm/am335x/system_config/: system.a
    ../../../../../../binary/armv7a/ewarm/utils/: utils.a
