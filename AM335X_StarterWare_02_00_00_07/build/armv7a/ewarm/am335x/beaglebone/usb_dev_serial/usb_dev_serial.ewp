# IAR project usb_dev_serial.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; beaglebone; am335x_15x15
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include\; ..\..\..\..\..\..\include\hw\; ..\..\..\..\..\..\usblib\include\; ..\..\..\..\..\..\include\armv7a\; ..\..\..\..\..\..\include\armv7a\am335x\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_dev_serial.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: usb_dev_serial.out
  ILINK.IlinkIcfFile: usb_dev_serial.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; beaglebone
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../../binary/armv7a/ewarm/am335x/drivers/: drivers.a
    ../../../../../../binary/armv7a/ewarm/am335x/beaglebone/platform/: platform.a
    ../../../../../../binary/armv7a/ewarm/am335x/system_config/: system.a
    ../../../../../../examples/beaglebone/usb_dev_serial/: Usb_dev_serial.c usb_serial_structs.c ustdlib.c
    ../../../../../../binary/armv7a/ewarm/am335x/usblib/: usblib.a
    ../../../../../../binary/armv7a/ewarm/utils/: utils.a
