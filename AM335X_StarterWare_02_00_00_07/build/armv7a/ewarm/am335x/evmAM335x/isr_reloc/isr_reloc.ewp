# IAR project isr_reloc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am335x TexasInstruments am335x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\include\armv7a\am335x
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\am335x
  OBJCOPY.OOCOutputFile: dmtimerCounter.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: dmtimerCounter.out
  ILINK.IlinkIcfFile: dmtimerCounter.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../../system_config/armv7a/ewarm/: cp15.S cpu.S
    ../../../../../../examples/evmAM335x/isr_reloc/: dmtimerCounter.c exceptionhandler_ewarm.S init_ewarm.S
    ../../../../../../binary/armv7a/ewarm/am335x/drivers/: drivers.a
    ../../../../../../system_config/armv7a/am335x/: interrupt.c startup.c
    ../../../../../../binary/armv7a/ewarm/am335x/evmAM335x/platform/: platform.a
    ../../../../../../binary/armv7a/ewarm/utils/: utils.a
