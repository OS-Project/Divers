# IAR project usb_dev_comp_mouse_ser.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; am335x_15x15
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\usblib\include; ..\..\..\..\..\..\grlib\include; ..\..\..\..\..\..\include\armv7a
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usb_dev_comp_mouse_ser.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: usb_dev_comp_mouse_ser.out
  ILINK.IlinkIcfFile: usb_dev_comp_mouse_ser.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; am335x_15x15
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\grlib\include; ..\..\..\..\..\..\usblib\include; ..\..\..\..\..\..\include\armv7a
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\usblib\include; ..\..\..\..\..\..\grlib\include
  group (top)
    ../../../../../../binary/armv7a/ewarm/am335x/drivers/: drivers.a
    ../../../../../../binary/armv7a/ewarm/grlib/: libgr.a
    ../../../../../../binary/armv7a/ewarm/am335x/evmAM335x/platform/: platform.a
    ../../../../../../binary/armv7a/ewarm/am335x/system_config/: system.a
    ../../../../../../examples/evmAM335x/usb_dev_comp_mouse_ser/: touch.c usb_dev_chidcdc.c usb_dev_mouse.c usb_dev_serial.c usb_structs.c ustdlib.c
    ../../../../../../binary/armv7a/ewarm/am335x/usblib/: usblib.a
    ../../../../../../binary/armv7a/ewarm/utils/: utils.a
