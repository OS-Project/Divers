# IAR project uartEdma_Cache.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\include\armv7a\am335x
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uartEdma_Cache.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: uartEdma_Cache.out
  ILINK.IlinkIcfFile: uartEdma_Cache.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration Debug_CacheClean (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CACHE_CLEAN; am335x
  OBJCOPY.OOCOutputFile: uartEdma_CacheClean.bin
  ILINK.IlinkOutputFile: uartEdma_CacheClean.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x
  ICCARM.CCOptLevel: 3
configuration Release_CacheClean (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CACHE_CLEAN; am335x
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: uartEdma_CacheClean.bin
  ILINK.IlinkOutputFile: uartEdma_CacheClean.out
  group (top)
    ../../../../../../binary/armv7a/ewarm/am335x/drivers/: drivers.a
    ../../../../../../binary/armv7a/ewarm/am335x/evmskAM335x/platform/: platform.a
    ../../../../../../binary/armv7a/ewarm/am335x/system_config/: system.a
    ../../../../../../examples/evmskAM335x/cache_mmu/: uartEdma_Cache.c
    ../../../../../../binary/armv7a/ewarm/utils/: utils.a
