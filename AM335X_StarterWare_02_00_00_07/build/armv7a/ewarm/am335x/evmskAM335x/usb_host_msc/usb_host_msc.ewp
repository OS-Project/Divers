# IAR project usb_host_msc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; DMA_MODE
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\usblib\include; ..\..\..\..\..\..\grlib\include; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\third_party\fatfs\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_host_msc.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: usb_host_msc.out
  ILINK.IlinkIcfFile: usb_host_msc.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; DMA_MODE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\grlib\include; ..\..\..\..\..\..\usblib\include; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\third_party\fatfs\src
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\am335x
  group (top)
    ../../../../../../binary/armv7a/ewarm/am335x/drivers/: drivers.a
    ../../../../../../third_party/fatfs/port/: fat_usbmsc.c
    ../../../../../../third_party/fatfs/src/: ff.c
    ../../../../../../binary/armv7a/ewarm/grlib/: libgr.a
    ../../../../../../binary/armv7a/ewarm/am335x/evmskAM335x/platform/: platform.a
    ../../../../../../binary/armv7a/ewarm/am335x/system_config/: system.a
    ../../../../../../examples/evmskAM335x/usb_host_msc/: usb_host_msc.c
    ../../../../../../binary/armv7a/ewarm/am335x/usblib/: usblib.a
    ../../../../../../binary/armv7a/ewarm/utils/: utils.a
