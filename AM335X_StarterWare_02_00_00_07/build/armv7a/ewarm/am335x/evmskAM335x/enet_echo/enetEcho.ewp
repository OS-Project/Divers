# IAR project enetEcho.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; evmskAM335x
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\ipv4; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\lwip; ..\..\..\..\..\..\third_party\lwip-1.4.0; ..\..\..\..\..\..\third_party\lwip-1.4.0\ports\cpsw\include; ..\..\..\..\..\..\third_party\lwip-1.4.0\apps\echoserver_raw; ..\..\..\..\..\..\examples\evmskAM335x\enet_echo
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\am335x
  OBJCOPY.OOCOutputFile: enetEcho.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: enetEcho.out
  ILINK.IlinkIcfFile: enetEcho.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; evmskAM335x
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\ipv4; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\lwip; ..\..\..\..\..\..\third_party\lwip-1.4.0; ..\..\..\..\..\..\third_party\lwip-1.4.0\ports\cpsw\include; ..\..\..\..\..\..\third_party\lwip-1.4.0\apps\echoserver_raw; ..\..\..\..\..\..\examples\evmskAM335x\enet_echo; ..\..\..\..\..\..\include\armv7a
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../../binary/armv7a/ewarm/am335x/drivers/: drivers.a
    ../../../../../../third_party/lwip-1.4.0/apps/echoserver_raw/: echod.c
    ../../../../../../examples/evmskAM335x/enet_echo/: enetEcho.c
    ../../../../../../third_party/lwip-1.4.0/ports/cpsw/: lwiplib.c
    ../../../../../../binary/armv7a/ewarm/am335x/evmskAM335x/platform/: platform.a
    ../../../../../../binary/armv7a/ewarm/am335x/system_config/: system.a
    ../../../../../../binary/armv7a/ewarm/utils/: utils.a
