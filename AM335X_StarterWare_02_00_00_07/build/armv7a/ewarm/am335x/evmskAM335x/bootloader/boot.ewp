# IAR project boot.ewp, settings and files
configuration UART_Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; UART; evmskAM335x
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\bootloader\include; ..\..\..\..\..\..\mmcsdlib\include; ..\..\..\..\..\..\third_party\fatfs\src; ..\..\..\..\..\..\nandlib\include; ..\..\..\..\..\..\third_party\xmodem; ..\..\..\..\..\..\bootloader\include\armv7a\am335x
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\am335x
  OBJCOPY.OOCOutputFile: boot.bin
  ILINK.IlinkOutputFile: boot.out
  ILINK.IlinkIcfFile: boot.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration UART_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; UART; evmskAM335x
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\bootloader\include; ..\..\..\..\..\..\mmcsdlib\include; ..\..\..\..\..\..\third_party\fatfs\src; ..\..\..\..\..\..\nandlib\include; ..\..\..\..\..\..\bootloader\include\armv7a\am335x
  ICCARM.CCOptLevel: 3
configuration MMCSD_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: am335x; MMCSD; evmskAM335x
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\bootloader\include; ..\..\..\..\..\..\mmcsdlib\include; ..\..\..\..\..\..\third_party\fatfs\src; ..\..\..\..\..\..\nandlib\include; ..\..\..\..\..\..\third_party\xmodem; ..\..\..\..\..\..\bootloader\include\armv7a\am335x
  ICCARM.CCOptLevel: 1
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x402F0400" "MMCSD" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
configuration MMCSD_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; MMCSD; evmskAM335x
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  postbuild: as above
  group (top)
    ../../../../../../bootloader/src/: bl_copy.c bl_hsmmcsd.c bl_main.c bl_mcspi.c bl_nand.c bl_nandgpmc.c bl_uart.c
    ../../../../../../bootloader/src/armv7a/ewarm/: bl_init.S
    ../../../../../../bootloader/src/armv7a/am335x/: bl_platform.c
    ../../../../../../system_config/armv7a/: cache.c mmu.c
    ../../../../../../system_config/armv7a/ewarm/: cp15.S
    ../../../../../../third_party/xmodem/: crc16.c xmodem.c
    ../../../../../../binary/armv7a/ewarm/am335x/drivers/: drivers.a
    ../../../../../../third_party/fatfs/port/: fat_mmcsd.c
    ../../../../../../third_party/fatfs/src/: ff.c
    ../../../../../../binary/armv7a/ewarm/mmcsdlib/: libmmcsd.a
    ../../../../../../binary/armv7a/ewarm/nandlib/: nandlib.a
    ../../../../../../binary/armv7a/ewarm/am335x/evmskAM335x/platform/: platform.a
    ../../../../../../binary/armv7a/ewarm/am335x/system_config/: system.a
    ../../../../../../binary/armv7a/ewarm/utils/: utils.a
