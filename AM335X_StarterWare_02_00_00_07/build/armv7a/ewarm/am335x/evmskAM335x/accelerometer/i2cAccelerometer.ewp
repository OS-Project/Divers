# IAR project i2cAccelerometer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\include\armv7a
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\am335x
  OBJCOPY.OOCOutputFile: i2cAccelerometer.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: i2cAccelerometer.out
  ILINK.IlinkIcfFile: i2cAccelerometer.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../../binary/armv7a/ewarm/am335x/drivers/: drivers.a
    ../../../../../../examples/evmskAM335x/accelerometer/: i2cAccelerometer.c
    ../../../../../../binary/armv7a/ewarm/am335x/evmskAM335x/platform/: platform.a
    ../../../../../../binary/armv7a/ewarm/am335x/system_config/: system.a
    ../../../../../../binary/armv7a/ewarm/utils/: utils.a
